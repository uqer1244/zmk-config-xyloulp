## boards/shields/xyloulp/Kconfig.defconfig
```kconfig
if SHIELD_XYLOULP

config ZMK_KEYBOARD_NAME
    default "xyloulp"

endif # SHIELD_XYLOULP
```
